#pragma once
// Host stub for heltec-eink-modules — enough of the Adafruit-GFX surface that
// the sketch's real drawing code runs unchanged into a framebuffer we can dump
// to an image. Ten methods is the whole surface the sketch uses.
//
// This is not a display simulator in the sense of pretending to be e-ink. It
// is the same pixels the panel would be sent: every screen in the README is
// produced by calling the sketch's own display functions through this.
#include <cstdint>
#include <cstring>
#include <cstdio>
#include <string>

#define BLACK 0
#define WHITE 1

// Adafruit GFX classic 5x7 font, printable ASCII (32-126). Column-major,
// bit 0 = top row.
static const uint8_t GFX_FONT5X7[95][5] = {
  {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},
  {0x14,0x7F,0x14,0x7F,0x14},{0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},
  {0x36,0x49,0x55,0x22,0x50},{0x00,0x05,0x03,0x00,0x00},{0x00,0x1C,0x22,0x41,0x00},
  {0x00,0x41,0x22,0x1C,0x00},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08},
  {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x60,0x60,0x00,0x00},
  {0x20,0x10,0x08,0x04,0x02},{0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},
  {0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4B,0x31},{0x18,0x14,0x12,0x7F,0x10},
  {0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03},
  {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1E},{0x00,0x36,0x36,0x00,0x00},
  {0x00,0x56,0x36,0x00,0x00},{0x00,0x08,0x14,0x22,0x41},{0x14,0x14,0x14,0x14,0x14},
  {0x41,0x22,0x14,0x08,0x00},{0x02,0x01,0x51,0x09,0x06},{0x32,0x49,0x79,0x41,0x3E},
  {0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22},
  {0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x01,0x01},
  {0x3E,0x41,0x41,0x51,0x32},{0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},
  {0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41},{0x7F,0x40,0x40,0x40,0x40},
  {0x7F,0x02,0x04,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E},
  {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},
  {0x46,0x49,0x49,0x49,0x31},{0x01,0x01,0x7F,0x01,0x01},{0x3F,0x40,0x40,0x40,0x3F},
  {0x1F,0x20,0x40,0x20,0x1F},{0x7F,0x20,0x18,0x20,0x7F},{0x63,0x14,0x08,0x14,0x63},
  {0x03,0x04,0x78,0x04,0x03},{0x61,0x51,0x49,0x45,0x43},{0x00,0x00,0x7F,0x41,0x41},
  {0x02,0x04,0x08,0x10,0x20},{0x41,0x41,0x7F,0x00,0x00},{0x04,0x02,0x01,0x02,0x04},
  {0x40,0x40,0x40,0x40,0x40},{0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},
  {0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20},{0x38,0x44,0x44,0x48,0x7F},
  {0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},{0x08,0x14,0x54,0x54,0x3C},
  {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x44,0x3D,0x00},
  {0x00,0x7F,0x10,0x28,0x44},{0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x18,0x04,0x78},
  {0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38},{0x7C,0x14,0x14,0x14,0x08},
  {0x08,0x14,0x14,0x18,0x7C},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20},
  {0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},
  {0x3C,0x40,0x30,0x40,0x3C},{0x44,0x28,0x10,0x28,0x44},{0x0C,0x50,0x50,0x50,0x3C},
  {0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00},{0x00,0x00,0x7F,0x00,0x00},
  {0x00,0x41,0x36,0x08,0x00},{0x08,0x08,0x2A,0x1C,0x08}
};

#define EINK_W 250
#define EINK_H 122

class EInkDisplay_WirelessPaperV1_2 {
public:
  uint8_t  fb[EINK_H][EINK_W];      // 1 = ink
  int      cx = 0, cy = 0;
  int      tsize = 1;
  uint8_t  tcolor = BLACK;
  int      updates = 0;

  EInkDisplay_WirelessPaperV1_2() { clearMemory(); }

  void landscape()   {}                       // the buffer is already 250x122
  void clearMemory() { memset(fb, 0, sizeof(fb)); }
  void update()      { updates++; }

  void setCursor(int x, int y)   { cx = x; cy = y; }
  void setTextSize(int s)        { tsize = s < 1 ? 1 : s; }
  void setTextColor(uint8_t c)   { tcolor = c; }

  void px(int x, int y, uint8_t color) {
    if (x < 0 || y < 0 || x >= EINK_W || y >= EINK_H) return;
    fb[y][x] = (color == BLACK) ? 1 : 0;
  }
  void fillRect(int x, int y, int w, int h, uint8_t color) {
    for (int j = 0; j < h; j++) for (int i = 0; i < w; i++) px(x + i, y + j, color);
  }
  void drawRect(int x, int y, int w, int h, uint8_t color) {
    for (int i = 0; i < w; i++) { px(x + i, y, color); px(x + i, y + h - 1, color); }
    for (int j = 0; j < h; j++) { px(x, y + j, color); px(x + w - 1, y + j, color); }
  }
  // 1bpp, MSB first, rows padded to whole bytes — Adafruit's layout.
  void drawBitmap(int x, int y, const uint8_t* bmp, int w, int h, uint8_t color) {
    int stride = (w + 7) / 8;
    for (int j = 0; j < h; j++)
      for (int i = 0; i < w; i++)
        if (bmp[j * stride + (i >> 3)] & (0x80 >> (i & 7))) px(x + i, y + j, color);
  }
  void drawChar(int x, int y, char c) {
    if (c < 32 || c > 126) c = '?';
    const uint8_t* g = GFX_FONT5X7[c - 32];
    for (int col = 0; col < 5; col++)
      for (int row = 0; row < 8; row++)
        if (g[col] & (1 << row))
          fillRect(x + col * tsize, y + row * tsize, tsize, tsize, tcolor);
  }
  void print(const std::string& s) {
    for (char c : s) {
      if (c == '\n') { cy += 8 * tsize; cx = 0; continue; }
      drawChar(cx, cy, c);
      cx += 6 * tsize;
    }
  }
  void print(const char* s)  { print(std::string(s ? s : "")); }
  // The sketch prints Arduino Strings. Matched by shape rather than by name so
  // the stub does not have to know what String is — and constrained, or it
  // also swallows every char array.
  template <typename T>
  auto print(const T& v) -> decltype(v.c_str(), void()) { print(std::string(v.c_str())); }
  void print(int v)          { char b[16]; snprintf(b, sizeof(b), "%d", v); print(b); }

  // Netpbm P1: one ASCII digit per pixel. Trivial to emit, trivial to read
  // back, and no image library on either side of the wall.
  void writePBM(const char* path) const {
    FILE* f = fopen(path, "w");
    if (!f) return;
    fprintf(f, "P1\n%d %d\n", EINK_W, EINK_H);
    for (int y = 0; y < EINK_H; y++) {
      for (int x = 0; x < EINK_W; x++) fputc(fb[y][x] ? '1' : '0', f);
      fputc('\n', f);
    }
    fclose(f);
  }
};
